require recipes-bsp/u-boot/var-uboot-qemu.inc